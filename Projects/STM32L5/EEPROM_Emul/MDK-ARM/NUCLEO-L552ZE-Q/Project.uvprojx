# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-L552ZE-Q (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6LangP=1 wLevel=4
  c define: STM32L552xx,USE_HAL_DRIVER
  c include: ../../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L5xx_Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32L5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0x30000000 size 0x30000
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32L5/: flash_interface.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_exti.c
  group Application/User
    ../../Src/: main.c stm32l5xx_it.c
software components: CMSIS:CORE 4.3.0

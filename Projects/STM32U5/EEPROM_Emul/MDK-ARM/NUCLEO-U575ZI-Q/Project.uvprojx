# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-STM32U575ZI-Q (6140001::V6.14.1::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U575xx,USE_HAL_DRIVER,FLASH_LINES_128B
  c include: ..\..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32U5xx_Nucleo;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32U5;..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../../Src/: main.c stm32u5xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_exti.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32U5/: flash_interface.c
software components: CMSIS:CORE 4.3.0

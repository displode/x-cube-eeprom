# Keil uVision project BLE_HeartRate_EEPROM_Emul.uvprojx, settings and files
target BLE_HeartRate_EEPROM_Emul (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BLE_HeartRate_EEPROM_Emul +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB55xx,DUALCORE_FLASH_SHARING
  c misc: --diag_suppress 1296
  c include: ../Core/Inc;../STM32_WPAN/App;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../Middlewares/ST/STM32_WPAN;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../Utilities/lpm/tiny_lpm;../../../../../Utilities/sequencer;../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../Middlewares/ST/STM32_WPAN/ble/core;../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: .\stm32wb55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_debug.c app_entry.c stm32_lpm_if.c hw_timerserver.c hw_uart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c dis_app.c hrs_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_ipcc.c stm32wbxx_hal_gpio.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c
  group Middlewares/STM32_WPAN
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl_if.c tl_mbox.c hci_tl.c shci_tl.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c dis.c hrs.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
  group Utilities
    ../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../Utilities/sequencer/: stm32_seq.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WB/: flash_interface.c
software components: CMSIS:CORE 4.3.0

# IAR project BLE_HeartRate_EEPROM_Emul.ewp, settings and files
configuration BLE_HeartRate_EEPROM_Emul (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER; STM32WB55xx; DUALCORE_FLASH_SHARING
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STM32_WPAN\App; ..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\Utilities\sequencer; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\template; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32WB; ..\..\..\..\..\Drivers\BSP\P-NUCLEO-WB55.Nucleo; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\tl; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities; ..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_HeartRate_EEPROM_Emul.hex
  ILINK.IlinkOutputFile: BLE_HeartRate_EEPROM_Emul.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c dis_app.c hrs_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WB/: flash_interface.c
  group Middlewares/STM32_WPAN
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: dis.c hrs.c svc_ctl.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Utilities
    ../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../Utilities/sequencer/: stm32_seq.c

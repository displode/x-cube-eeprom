# Keil uVision project EEPROM_Emul.uvprojx, settings and files
target NUCLEO-WL55JC (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EEPROM_Emul +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WL55xx,CORE_CM4,USE_HAL_DRIVER
  c include: ../../Inc;../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\stm32wl55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../../Src/: main.c stm32wlxx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_gpio.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c
  group Drivers/CMSIS
    ../../Src/: system_stm32wlxx.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WL/: flash_interface.c
  group Drivers/BSP/NUCLEO-WL55JC
    ../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c

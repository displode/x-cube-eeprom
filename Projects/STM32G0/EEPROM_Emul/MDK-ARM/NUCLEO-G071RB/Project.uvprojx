# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G071RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: NUCLEO-G071RB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G071xx,
  c include: ../../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G0xx_Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32G0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32G0/: flash_interface.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c
  group Application/User
    ../../Src/: main.c stm32g0xx_it.c
software components: CMSIS:CORE 4.3.0

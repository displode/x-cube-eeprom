# IAR project Project.ewp, settings and files
configuration NUCLEO-G431RB (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G431xx; USE_HAL_DRIVER; USE_STM32G4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32G4xx_Nucleo; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32G4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-G431RB.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Source\Templates\iar\linker\stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/iar/: startup_stm32g431xx.s
  group Application/User
    ../../Src/: main.c stm32g4xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32G4/: flash_interface.c

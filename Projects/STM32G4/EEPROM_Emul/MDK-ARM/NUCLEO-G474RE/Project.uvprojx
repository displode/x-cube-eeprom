# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NUCLEO-G474RE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,
  c include: ../../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G4xx_Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32G4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32G4/: flash_interface.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_exti.c
  group Application/User
    ../../Src/: main.c stm32g4xx_it.c
software components: CMSIS:CORE 5.3.0
